## boards/shields/bleptestpad/Kconfig.defconfig
```kconfig
if SHIELD_BLEPTESTPAD

config ZMK_KEYBOARD_NAME
    default "bleptestpad"

endif

config SPI
	default y
```
